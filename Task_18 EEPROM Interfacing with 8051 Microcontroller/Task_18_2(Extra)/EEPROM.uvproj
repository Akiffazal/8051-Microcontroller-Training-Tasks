# Keil uVision project EEPROM.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: EEPROM +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c 24C02.c 24C02.h LCD.c LCD.h Includes.h I2C.h I2C.c
