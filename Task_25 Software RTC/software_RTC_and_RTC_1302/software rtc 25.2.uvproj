# Keil uVision project software rtc 25.2.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: software rtc 25.2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: DS1302.h DS1302.c main.c
