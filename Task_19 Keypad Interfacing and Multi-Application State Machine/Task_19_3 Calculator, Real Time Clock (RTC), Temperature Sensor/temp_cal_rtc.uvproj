# Keil uVision project temp_cal_rtc.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: temp_cal_rtc +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c main (2).c CALCULATOR.c CALCULATOR.h LCD.c LCD.h 7sd.c mainstate.c RTC.h TEMP.c TEMP.h
