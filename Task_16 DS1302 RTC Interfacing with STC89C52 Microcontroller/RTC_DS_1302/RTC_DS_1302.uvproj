# Keil uVision project RTC_DS_1302.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: RTC_DS_1302 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c DS1302.c DS1302.h LCD1602.c void ShowHexNum(unsigned char Line, unsigned char Column, unsigned int Number, unsigned char Length) {.h LCD1602.h
