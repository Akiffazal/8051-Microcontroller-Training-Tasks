# Keil uVision project Temp_Sensor.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: Temp_Sensor +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c Temp.c Temp.h LCD.c LCD.h 7sd.c 7sd.h
